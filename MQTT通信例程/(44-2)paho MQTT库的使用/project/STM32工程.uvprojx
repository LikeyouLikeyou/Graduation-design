# Keil uVision project STM32工程.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\Peripheral;..\core;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group Peripheral
    ../Peripheral/: delay.c mymqtt.c printf.c usart3.c timer.c esp8266.c
  group StdPeriph_Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c
software components: IoT Utility:MQTTPacket 1.1.0
