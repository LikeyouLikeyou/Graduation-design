# Keil uVision project STM32C8T6工程.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32C8T6工程 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\Peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group Peripheral
    ../Peripheral/: delay.c oled.c printf.c oledfont.h
  group StdPeriph_Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
